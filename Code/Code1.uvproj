# Keil uVision project Code1.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Code1
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group System
    ./: startup_LPC11xx.s system_LPC11xx.c cpu_lpc1000.c Retarget.c
  group Main
    ./: main.c timer32.c mpu6050.c
  group Drivers
    ./: gpio.c i2c.c ssp.c uart.c
  group Devices
    ./: AX12.c kalman.c nrf24l01.c complementary.c
